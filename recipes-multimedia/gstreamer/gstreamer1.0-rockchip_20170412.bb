# Copyright (C) 2016 - 2017 Randy Li <ayaka@soulik.info>
# Released under the GNU GENERAL PUBLIC LICENSE Version 2
# (see COPYING.GPLv2 for the terms)
include gstreamer1.0-rockchip.inc

SRCREV = "e18a9eedec51608caf36cc02c7fb3765bf5acc8a"
SRC_URI = "git://github.com/rockchip-linux/gstreamer-rockchip.git;branch=develop"

S = "${WORKDIR}/git"
