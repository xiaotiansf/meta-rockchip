# Copyright (C) 2017 Fuzhou Rockchip Electronics Co., Ltd
# Released under the MIT license (see COPYING.MIT for the terms)

PACKAGECONFIG += " gstreamer"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
