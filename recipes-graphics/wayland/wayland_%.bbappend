PV="1.13.0"

SRC_URI_remove = "file://0001-scanner-Use-unit32_t-instead-of-uint.patch"

SRC_URI[md5sum] = "cae152ed956da6de53f9727bc1c45039"
SRC_URI[sha256sum] = "69b052c031a61e89af7cc8780893d0da1e301492352aa449dee9345043e6fe51"
