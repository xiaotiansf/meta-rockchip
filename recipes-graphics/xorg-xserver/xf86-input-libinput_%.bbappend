PV = "0.25.1"

SRC_URI[md5sum] = "14003139614b25cc76c9a4cad059df89"
SRC_URI[sha256sum] = "489f7d591c9ef08463d4966e61f7c6ea433f5fcbb9f5370fb621da639a84c7e0"
