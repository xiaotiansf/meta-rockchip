PV = "1.6.1"

SRC_URI[md5sum] = "7e282344f8ed7ec5cf87ca9fc22674fb"
SRC_URI[sha256sum] = "9d816f13eee63bcca0e9c3bb652c52ab55f39be4d1b90b54e4bfd1dc92ef55a8"
